# Keil uVision project Project.uvprojx, settings and files
target STM32L476G-Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L476G-Discovery
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ..\APP;..\STM32L4xx_HAL_Driver\Inc\Legacy;..\STM32L4xx_HAL_Driver\Inc;..\BSP;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\FreeRTOS\Source\CMSIS_RTOS;..\FreeRTOS\Source\include;..\APP\product;..\APP\sensor;..\APP\sensor\7_infraredTemp
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Drivers/CMSIS
    ../APP/: system_stm32l4xx.c
  group Middlewares/FreeRTOS/portable
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Doc
    ../: readme.txt
  group Middlewares/FreeRTOS
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Example/MDK-ARM
    ./: startup_stm32l431xx.s
  group Drivers/BSP
    ../BSP/: AD7792.c bsp_led.c i2c.c spi.c uart.c W25Q128.c ds3231.c adc12_a.c
  group Drivers/STM32L4xx_HAL_Driver
    ../STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_spi.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_pwr.c
  group Application
    ../APP/: stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Application/product
    ../APP/product/: command.c main.c sysinit.c uartprocess.c
  group Application/sensor
    ../APP/sensor/: sensor_basic.c sensor_process.c
  group Application/sensor/7_infraredTemp
    ../APP/sensor/7_IRTemp/: EarthTemp_Hal.c EarthTemp_Sample.c EarthTemp_Sensor.c
software components: CMSIS:CORE 5.0.1
